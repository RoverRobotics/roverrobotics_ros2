Commit message: updated MITI 65 URDF

File: roverrobotics_description/urdf/miti_65.urdf (robot description, URDF)
Before this commit: robot rover_miti, 6 links, 5 joints
Joints:
- joint base_to_chassis: origin xyz=0 0 0.061 -> xyz=0 0 0.062
