Commit message: Update max_150.urdf

File: roverrobotics_description/urdf/max_150.urdf (robot description, URDF)
Before this commit: robot rover_max, 6 links, 5 joints
Joints:
- joint base_to_chassis: origin xyz=0 0 0.165 -> xyz=0 0 0.1645
